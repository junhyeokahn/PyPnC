Commit message: manipulator working

File: robot_model/manipulator/three_link_manipulator.urdf (robot description, URDF)
Before this commit: robot 2link_robot, 5 links, 4 joints
Links:
- removed link l0
- added link world, mass 1.
Joints:
- joint j0: parent l0 -> world
